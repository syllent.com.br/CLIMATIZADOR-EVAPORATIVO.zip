Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: f31c2926-91f3-4c07-8868-4fc9878b25e6, VersionGUID: fc051e47-af6c-41d4-893a-f47c13fa63d4, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordenadas compartilhadas, ProjectSite: Terreno padrão]
File name: Motobomba de circulação para climatizadores.ifc
Time: 2025-02-02T19:05:30-03:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.0.13 (PTB) - IFC 24.3.0.13

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Cabeça de 8 mm (6)
Name | LongName | Elevation (mm)
Sapata B.O. | Sapata B.O. | -4600
Sapata T.O. | Sapata T.O. | -4300
Laje T.O. | Laje T.O. | -4000
Parede da fundação T.O. | Parede da fundação T.O. | -300
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcBuildingElementProxy: Motobomba de circulação para climatizadores:Padrão, Motobomba de circulação para climatizadores:Padrão:361287
In: Nível 1
Type - Material: Aço Inox, Plástico branco - Syllent, Plástico prego - Syllent
Type - Pset_ManufacturerTypeInformation - Manufacturer: Syllent
Pset_BuildingElementProxyCommon - Reference: Padrão; sets with these values: 2

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
InPort_361287_1 | SINK
OutPort_361287_2 | SOURCE
